# Keil uVision project Am32F051.uvprojx, settings and files
target AM32REF_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AM32_FIREFLY_G20_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, FIREFLY_G20_F051
  c include: ..\mcu\f051\Drivers\CMSIS\Include;..\mcu\f051\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\mcu\f051\Drivers\STM32F0xx_HAL_Driver\Inc;..\mcu\f051\Inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
  group startup
    ../Mcu/f051/Startup/mdk/: startup_stm32f051k8.s
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c kiss_telemetry.c
  group f051
    ../Mcu/f051/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32f0xx_it.c system_stm32f0xx.c
  group Drivers/STM32F0xx_LL_Driver
    ../Mcu/f051/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group Inc
    ../Inc/: version.h targets.h sounds.h signal.h functions.h firmwareversion.h eeprom.h dshot.h common.h kiss_telemetry.h
target FD6288_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_FD6288_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, FD6288_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target IFLIGHT_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_IFLIGHT_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, IFLIGHT_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target AGFRC_V2_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_AGFCC_V2_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, AGFRC_V2_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target MP6531_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_MP6531_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, MP6531_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target REPEAT_DRIVE_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_REPEAT_DRIVE_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, REPEAT_DRIVE_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target RAZOR32_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_RAZOR32_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, RAZOR32_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target TMOTOR45_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_TMOTOR45_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, TMOTOR45_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target HGLRC_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_HGLRC_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, HGLRC_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target SISKIN_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_SISKIN_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, SISKIN_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target DIATONE_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_DIATONE_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, DIATONE_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target MAMBA_F40PRO_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_MAMBA_F40PRO_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, MAMBA_F40PRO_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target MAMBA_F50PRO_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_MAMBA_F50PRO_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, MAMBA_F50PRO_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target MAMBA_F60PRO_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_MAMBA_F60PRO_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, MAMBA_F60PRO_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target WRAITH32V1_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_WRAITH32V1_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, WRAITH32V1_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target WRAITH32V2_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_WRAITH32V2_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, WRAITH32V2_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target FLASHHOBBY_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_FLASHHOBBY_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, FLASHHOBBY_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target AIKON20X20_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_AIKON20X20_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, AIKON20X20_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target AIKONSINGLE_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_AIKONSINGLE_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, AIKONSINGLE_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target CRTEENSY_HILARIESC_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_CRTEENSY_HILARIESC_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, CRTEENSY_HILARIESC_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target FLYCOLOR_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_FLYCOLOR_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, FLYCOLOR_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target HVFLYCOLOR_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_HVFLYCOLOR_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, HVFLYCOLOR_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target SKYSTARS_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_SKYSTARS_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, SKYSTARS_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target BLPWR_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_BLPWR_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, BLPWR_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target NEUTRONRC_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_NEUTRONRC_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, NEUTRONRC_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target RHINO80A_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_RHINO80A_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, RHINO80A_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target WOLFE (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_WOLFE_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, WOLFE_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target PB450_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_PB450_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, PB450_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target PB054_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_PB054_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, PB054_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target PB405_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_PB405_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, PB405_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target OCDRC_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_OCDRC_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, OCDRC_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target SDMODEL_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_SDMODEL_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, SDMODEL_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target GSPACE_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_GSPACE_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, GSPACE_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target SEQURE_TEST_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_SEQURE_TEST_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, SEQURE_TEST_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target LUMINOUSBEES_F051 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_LUMINOUSBEES_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, LUMINOUSBEES_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target DM_VISHNU32 (6190000::V6.19::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_DM_VISHNU32_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, DM_VISHNU32_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
target FIREFLY_G20_F051 (6230000::V6.23::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: AM32_FIREFLY_G20_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, FIREFLY_G20_F051
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f051\Am32 32kb_f051.sct
software components: CMSIS:CORE 5.5.0
